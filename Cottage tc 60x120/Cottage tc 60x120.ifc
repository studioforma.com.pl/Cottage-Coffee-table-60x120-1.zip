Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Cottage tc 60x120.ifc
Time: 2022-02-14T16:42:13
Author: utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (121)
Name
 | Componente#113 - Description: Componente#113; ObjectType: SketchupComponentInstance
 | Componente#103 - Description: Componente#103; ObjectType: SketchupComponentInstance
 | Componente#116 - Description: Componente#116; ObjectType: SketchupComponentInstance
 | Componente#118 - Description: Componente#118; ObjectType: SketchupComponentInstance
 | Componente#111 - Description: Componente#111; ObjectType: SketchupComponentInstance
 | Componente#121 - Description: Componente#121; ObjectType: SketchupComponentInstance
 | Componente#117 - Description: Componente#117; ObjectType: SketchupComponentInstance
 | Componente#108 - Description: Componente#108; ObjectType: SketchupComponentInstance
 | Componente#112 - Description: Componente#112; ObjectType: SketchupComponentInstance
 | Componente#120 - Description: Componente#120; ObjectType: SketchupComponentInstance
 | Componente#119 - Description: Componente#119; ObjectType: SketchupComponentInstance
 | Componente#109 - Description: Componente#109; ObjectType: SketchupComponentInstance
 | Componente#110 - Description: Componente#110; ObjectType: SketchupComponentInstance
 | Componente#115 - Description: Componente#115; ObjectType: SketchupComponentInstance
 | Componente#114 - Description: Componente#114; ObjectType: SketchupComponentInstance
 | Componente#104 - Description: Componente#104; ObjectType: SketchupComponentInstance
 | Componente#106 - Description: Componente#106; ObjectType: SketchupComponentInstance
 | Componente#105 - Description: Componente#105; ObjectType: SketchupComponentInstance
 | Componente#107 - Description: Componente#107; ObjectType: SketchupComponentInstance
 | Componente#16 - Description: Componente#16; ObjectType: SketchupComponentInstance
 | Componente#10 - Description: Componente#10; ObjectType: SketchupComponentInstance
 | Componente#5 - Description: Componente#5; ObjectType: SketchupComponentInstance
 | Componente#30 - Description: Componente#30; ObjectType: SketchupComponentInstance
 | Componente#7 - Description: Componente#7; ObjectType: SketchupComponentInstance
 | Componente#14 - Description: Componente#14; ObjectType: SketchupComponentInstance
 | Componente#21 - Description: Componente#21; ObjectType: SketchupComponentInstance
 | Componente#2 - Description: Componente#2; ObjectType: SketchupComponentInstance
 | Componente#1 - Description: Componente#1; ObjectType: SketchupComponentInstance
 | Componente#8 - Description: Componente#8; ObjectType: SketchupComponentInstance
 | Componente#17 - Description: Componente#17; ObjectType: SketchupComponentInstance
 | Componente#25 - Description: Componente#25; ObjectType: SketchupComponentInstance
 | Componente#24 - Description: Componente#24; ObjectType: SketchupComponentInstance
 | Componente#6 - Description: Componente#6; ObjectType: SketchupComponentInstance
 | Componente#3 - Description: Componente#3; ObjectType: SketchupComponentInstance
 | Componente#22 - Description: Componente#22; ObjectType: SketchupComponentInstance
 | Componente#27 - Description: Componente#27; ObjectType: SketchupComponentInstance
 | Componente#18 - Description: Componente#18; ObjectType: SketchupComponentInstance
 | Componente#11 - Description: Componente#11; ObjectType: SketchupComponentInstance
 | Componente#13 - Description: Componente#13; ObjectType: SketchupComponentInstance
 | Componente#9 - Description: Componente#9; ObjectType: SketchupComponentInstance
 | Componente#38 - Description: Componente#38; ObjectType: SketchupComponentInstance
 | Componente#31 - Description: Componente#31; ObjectType: SketchupComponentInstance
 | Componente#12 - Description: Componente#12; ObjectType: SketchupComponentInstance
 | Componente#28 - Description: Componente#28; ObjectType: SketchupComponentInstance
 | Componente#4 - Description: Componente#4; ObjectType: SketchupComponentInstance
 | Componente#26 - Description: Componente#26; ObjectType: SketchupComponentInstance
 | Componente#15 - Description: Componente#15; ObjectType: SketchupComponentInstance
 | Componente#35 - Description: Componente#35; ObjectType: SketchupComponentInstance
 | Componente#33 - Description: Componente#33; ObjectType: SketchupComponentInstance
 | Componente#34 - Description: Componente#34; ObjectType: SketchupComponentInstance
 | Componente#19 - Description: Componente#19; ObjectType: SketchupComponentInstance
 | Componente#36 - Description: Componente#36; ObjectType: SketchupComponentInstance
 | Componente#20 - Description: Componente#20; ObjectType: SketchupComponentInstance
 | Componente#32 - Description: Componente#32; ObjectType: SketchupComponentInstance
 | Componente#39 - Description: Componente#39; ObjectType: SketchupComponentInstance
 | Componente#37 - Description: Componente#37; ObjectType: SketchupComponentInstance
 | Componente#29 - Description: Componente#29; ObjectType: SketchupComponentInstance
 | Componente#23 - Description: Componente#23; ObjectType: SketchupComponentInstance
 | Componente#40 - Description: Componente#40; ObjectType: SketchupComponentInstance
 | Componente#41 - Description: Componente#41; ObjectType: SketchupComponentInstance
 | Componente#42 - Description: Componente#42; ObjectType: SketchupComponentInstance
 | Componente#43 - Description: Componente#43; ObjectType: SketchupComponentInstance
 | Componente#44 - Description: Componente#44; ObjectType: SketchupComponentInstance
 | Componente#45 - Description: Componente#45; ObjectType: SketchupComponentInstance
 | Componente#46 - Description: Componente#46; ObjectType: SketchupComponentInstance
 | Componente#47 - Description: Componente#47; ObjectType: SketchupComponentInstance
 | Componente#48 - Description: Componente#48; ObjectType: SketchupComponentInstance
 | Componente#49 - Description: Componente#49; ObjectType: SketchupComponentInstance
 | Componente#50 - Description: Componente#50; ObjectType: SketchupComponentInstance
 | Componente#51 - Description: Componente#51; ObjectType: SketchupComponentInstance
 | Componente#52 - Description: Componente#52; ObjectType: SketchupComponentInstance
 | Componente#53 - Description: Componente#53; ObjectType: SketchupComponentInstance
 | Componente#54 - Description: Componente#54; ObjectType: SketchupComponentInstance
 | Componente#55 - Description: Componente#55; ObjectType: SketchupComponentInstance
 | Componente#56 - Description: Componente#56; ObjectType: SketchupComponentInstance
 | Componente#57 - Description: Componente#57; ObjectType: SketchupComponentInstance
 | Componente#58 - Description: Componente#58; ObjectType: SketchupComponentInstance
 | Componente#59 - Description: Componente#59; ObjectType: SketchupComponentInstance
 | Componente#60 - Description: Componente#60; ObjectType: SketchupComponentInstance
 | Componente#61 - Description: Componente#61; ObjectType: SketchupComponentInstance
 | Componente#62 - Description: Componente#62; ObjectType: SketchupComponentInstance
 | Componente#63 - Description: Componente#63; ObjectType: SketchupComponentInstance
 | Componente#64 - Description: Componente#64; ObjectType: SketchupComponentInstance
 | Componente#65 - Description: Componente#65; ObjectType: SketchupComponentInstance
 | Componente#66 - Description: Componente#66; ObjectType: SketchupComponentInstance
 | Componente#67 - Description: Componente#67; ObjectType: SketchupComponentInstance
 | Componente#68 - Description: Componente#68; ObjectType: SketchupComponentInstance
 | Componente#69 - Description: Componente#69; ObjectType: SketchupComponentInstance
 | Componente#70 - Description: Componente#70; ObjectType: SketchupComponentInstance
 | Componente#71 - Description: Componente#71; ObjectType: SketchupComponentInstance
 | Componente#72 - Description: Componente#72; ObjectType: SketchupComponentInstance
 | Componente#73 - Description: Componente#73; ObjectType: SketchupComponentInstance
 | Componente#74 - Description: Componente#74; ObjectType: SketchupComponentInstance
 | Componente#75 - Description: Componente#75; ObjectType: SketchupComponentInstance
 | Componente#76 - Description: Componente#76; ObjectType: SketchupComponentInstance
 | Componente#77 - Description: Componente#77; ObjectType: SketchupComponentInstance
 | Componente#78 - Description: Componente#78; ObjectType: SketchupComponentInstance
 | Componente#79 - Description: Componente#79; ObjectType: SketchupComponentInstance
 | Componente#80 - Description: Componente#80; ObjectType: SketchupComponentInstance
 | Componente#81 - Description: Componente#81; ObjectType: SketchupComponentInstance
 | Componente#82 - Description: Componente#82; ObjectType: SketchupComponentInstance
 | Componente#83 - Description: Componente#83; ObjectType: SketchupComponentInstance
 | Componente#84 - Description: Componente#84; ObjectType: SketchupComponentInstance
 | Componente#85 - Description: Componente#85; ObjectType: SketchupComponentInstance
 | Componente#86 - Description: Componente#86; ObjectType: SketchupComponentInstance
 | Componente#87 - Description: Componente#87; ObjectType: SketchupComponentInstance
 | Componente#88 - Description: Componente#88; ObjectType: SketchupComponentInstance
 | Componente#89 - Description: Componente#89; ObjectType: SketchupComponentInstance
 | Componente#90 - Description: Componente#90; ObjectType: SketchupComponentInstance
 | Componente#91 - Description: Componente#91; ObjectType: SketchupComponentInstance
 | Componente#92 - Description: Componente#92; ObjectType: SketchupComponentInstance
 | Componente#93 - Description: Componente#93; ObjectType: SketchupComponentInstance
 | Componente#94 - Description: Componente#94; ObjectType: SketchupComponentInstance
 | Componente#95 - Description: Componente#95; ObjectType: SketchupComponentInstance
 | Componente#96 - Description: Componente#96; ObjectType: SketchupComponentInstance
 | Componente#97 - Description: Componente#97; ObjectType: SketchupComponentInstance
 | Componente#98 - Description: Componente#98; ObjectType: SketchupComponentInstance
 | Componente#99 - Description: Componente#99; ObjectType: SketchupComponentInstance
 | Componente#100 - Description: Componente#100; ObjectType: SketchupComponentInstance
 | Componente#101 - Description: Componente#101; ObjectType: SketchupComponentInstance
 | Componente#102 - Description: Componente#102; ObjectType: SketchupComponentInstance
